Commit message: centroidal inertia isometry computation used for frontiers paper

File: robot_model/valkyrie/valkyrie.urdf (robot description, URDF)
Before this commit: robot valkyrie, 46 links, 45 joints
Links:
- link torso: mass 39.47 -> 25.47
