Commit message: med7 controller working in pybullet

File: robot_model/med7/urdf/med7.urdf (robot description, URDF)
Before this commit: robot med7, 13 links, 12 joints
Links:
- link link_ee: mass None -> 1e-9
- link link_inst_ee: mass None -> 1e-9
