Commit message: removed world frame in hubo URDF

File: robot_model/hubo/URDF_HuboPlus_Float.urdf (robot description, URDF)
Before this commit: robot huboplus, 61 links, 60 joints
Links:
- removed link World
Joints:
- removed joint W2B
