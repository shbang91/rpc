Commit message: last experiment

File: robot_model/draco/draco3_big_feet.urdf (robot description, URDF)
Before this commit: robot draco, 40 links, 39 joints
Links:
- link torso_link: mass 6.456 -> 7.856
